# PACKAGECONFIG_class-target_remove = "x11"
# PACKAGECONFIG_class-target_append = " wayland"
